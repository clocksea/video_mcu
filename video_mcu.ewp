# IAR project video_mcu.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LM3Sx7xx TexasInstruments LM3Sx7xx
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\Luminary; $PROJ_DIR$; inc; inc\driverlib; utils
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: $TOOLKIT_DIR$\INC\Luminary; $PROJ_DIR$; inc; inc\driverlib
  OBJCOPY.OOCOutputFile: video_mcu.srec
  ILINK.IlinkOutputFile: video_mcu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group lib
    lib/: driverlib.a
  group src
    src/: 920_uart.c cmd_proc.c main.c my_uart.c PLL.c radio.c
    utils/: uartstdio.c
  group startup
    src/: startup_ewarm.c
